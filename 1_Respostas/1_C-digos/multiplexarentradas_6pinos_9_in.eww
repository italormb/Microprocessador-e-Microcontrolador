<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\multiplexarentradas_6pinos_9_in.ewp</path>
  </project>
  <batchBuild/>
</workspace>


