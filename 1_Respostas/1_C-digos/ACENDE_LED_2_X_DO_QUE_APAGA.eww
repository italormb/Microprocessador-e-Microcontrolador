<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ACENDE_LED_2_X_DO_QUE_APAGA.ewp</path>
  </project>
  <batchBuild/>
</workspace>


