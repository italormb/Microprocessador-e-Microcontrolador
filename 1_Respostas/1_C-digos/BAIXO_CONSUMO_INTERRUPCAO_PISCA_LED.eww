<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\ASSEMBLY\BAIXO_CONSUMO_INTERUPCAO_PISCA_LED.ewp</path>
  </project>
  <batchBuild/>
</workspace>


