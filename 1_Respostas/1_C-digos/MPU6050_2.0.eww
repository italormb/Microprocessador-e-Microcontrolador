<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MPU6050_2.0.ewp</path>
  </project>
  <batchBuild/>
</workspace>


