<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ACENDE_LED_QUANDO_BOTAO_EH_PRESSIONADO.ewp</path>
  </project>
  <batchBuild/>
</workspace>


